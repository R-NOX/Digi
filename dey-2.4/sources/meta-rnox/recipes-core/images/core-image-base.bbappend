IMAGE_INSTALL += "helloworld"

#IMAGE_INSTALL_append = " helloworld"
